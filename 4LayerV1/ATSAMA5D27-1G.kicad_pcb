# Repository Groboards/giant-board-design-files

File README.md:

# giant-board-design-files
Giant Boards kicad design files

These files are licensed under: Creative Commons Attribution-ShareAlike 4.0 International Public License
https://choosealicense.com/licenses/cc-by-4.0/

## KiCad design 4LayerV1/ATSAMA5D27-1G.kicad_pcb

Parts:
C1, C18, C19, C20, C21, C26, C37, C38, C40, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53, C55, C56, C57, C58, C59, C60, C61, C62, C64, C65, C70, C71, C72, C73, C74, C75, C76, C77, C79, C86, C87, C88, C89, C92, C93, C94, C95: 0.1uF; C_0402_1005Metric
C2, C11, C39, C41, C63, C90, C91: 4.7uF; C_0402_1005Metric
C3: 47nF; C_0402_1005Metric
C4, C6, C12, C17, C30, C33, C67, C69: 2.2uF; C_0402_1005Metric
C5, C7, C8, C9, C10, C13, C14, C15, C16, C22, C23, C24, C25, C28, C85: 10uF; C_0402_1005Metric
C27, C29, C31, C32, C34, C36: 0.01uF; C_0402_1005Metric
C35, C54: 1uF; C_0402_1005Metric
C96, C97: 8pF, 50V; C_0402_1005Metric
C98, C99: 12pF, 50V; C_0402_1005Metric
C100: 10pF, 25V; C_0402_1005Metric
D2: YELLOW; LED_0603_1608Metric
D3: BAT54C; SC-59
D4: ORANGE; LED_0603_1608Metric
D5: GREEN; LED_0603_1608Metric
FB1, FB2, FB3, FB4, FB5, FB6, FB7: BLM15AG100SH1D; L_0402_1005Metric
J1: Conn_01x16; Pin_Header_Straight_1x16_Pitch2.54mm
J2: Conn_01x12; Pin_Header_Straight_1x12_Pitch2.54mm
J3: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J4: Conn_01x02; JST_PH_S2B-PH-SM4-TB_02x2.00mm_Angled
J5: Conn_01x02; Pin_Header_Straight_2x01_Pitch2.54mm
J6: 1051620001; Manufacturer_Part_Number 1051620001
J7: USB_B_Micro; FRAMATOME_10104111-0001LF
L1, L2, L3: NR3015T2R2M; L_Taiyo-Yuden_NR-30xx
L6, L11, L12: MLZ1608N100L; L_0603
MH1, MH2: Conn_01x01; MountingHole_2.7mm_M2.5_DIN965_Pad
MH3, MH4: MountingHole; MountingHole_2.7mm_M2.5
NT1, NT2: Net-Tie_2; NetTie-2_SMD_Padsmall
PB1: POWER-ON; MINI_PUSHBUTTON
Q1, Q2, Q3, Q4, Q5: BSS138; SOT-23
R1: 47K; R_0402_1005Metric
R2: 1K; R_0402_1005Metric
R3, R9, R26, R32, R37, R39: 10K; R_0402_1005Metric
R4, R24, R25, R27: 100R, 1%; R_0402_1005Metric
R5, R6, R14, R16, R18, R22: 100K; R_0402_1005Metric
R7, R8, R19, R20: 1.5K, 1%; R_0402_1005Metric
R10: 2.2M 1%; R_0402_1005Metric
R11: 1.5M 1%; R_0402_1005Metric
R12: 2.43K 1%; R_0402_1005Metric
R15: 49.9K; R_0402_1005Metric
R17, R21, R23: 2.2R; R_0402_1005Metric
R29: 5.6K; R_0402_1005Metric
R30, R31, R33, R34: 68K; R_0402_1005Metric
R35, R38: 330R; R_0402_1005Metric
R36: 0R; R_0402_1005Metric
TP1, TP2: TestPoint; TestPoint_Pad_1.0x1.0mm
U1: ATSAMA5D27C-D1G; BGA289C80P17X17_1400X1400X120N
U2: ACT8945AQJ305-T; QFN-40-1EP_5x5mm_Pitch0.4mm
U3: MIC5247-2.0; SOT-23-5
Y1: NX2012SA_32-768KHz; Crystal_SMD_MicroCrystal_CC8V-T1A-2pin_2.0x1.2mm
Y2: NX2016SA_24MHz; Crystal_SMD_2016-4pin_2.0x1.6mm

Connections:
AD0: J1.10, U1.L8
AD1: J1.7, U1.L2
AD2: J1.6, U1.P1
AD3: J1.9, U1.L6
AD4: J1.5, U1.T1
AD5: J1.8, U1.L4
ADTRG-IRQ: J2.5, U1.M8
ADVREF: J1.3, NT2.1, U1.L9
CLK_AUDIO: U1.T8
DATA: U1.T12
DDR_VREF: C64.2, C65.1, R19.1, R20.2, U1.F11, U1.J10
FLEXCOM4_IO1: J2.4, U1.N1
GND: C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C65.2, C67.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C79.2, C85.2, C86.2, C87.2, C88.2, C89.2, C90.2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
GNDUTMMI: C94.2, C100.2, NT1.1, R29.1, U1.M6
I2C_TWCK0: J2.11, U1.N10
I2C_TWCK1: R8.2, U1.H1, U2.26
I2C_TWD0: J2.12, U1.G7
I2C_TWD1: R7.2, U1.H7, U2.27
LOWQ#: U1.P3
NRST: R24.2, R37.1, U2.11
unnamed: C1.1, Q4.1 (G), R6.1
unnamed: C1.2, R2.2
unnamed: C3.1, U2.1
unnamed: C35.1, C37.1, D3.3, U3.1, U3.3
unnamed: C39.1, C44.1, FB7.1, U1.M7
unnamed: C40.1, FB6.1, U1.R7
unnamed: C41.1, C45.1, L6.2, U1.R5
unnamed: C48.1, C51.1, C55.1, FB5.1, U1.J5, U1.K4
unnamed: C96.1, U1.U2, Y1.1
unnamed: C97.1, U1.U1, Y1.2
unnamed: C98.1, U1.U9, Y2.1
unnamed: C99.1, U1.U8, Y2.3
unnamed: C100.1, R29.2, U1.T6
unnamed: D2.1 (K), R4.1
unnamed: D4.1 (K), R35.1
unnamed: D5.1 (K), R38.1
unnamed: L1.1, U2.38
unnamed: L2.1, U2.36
unnamed: L3.1, U2.15
unnamed: L6.1, R17.1
unnamed: L11.1, R21.1
unnamed: L12.1, R23.1
unnamed: Q1.3 (D), Q2.1 (G), R1.2
unnamed: Q2.3 (D), R5.2, U2.10
unnamed: Q3.1 (G), Q5.3 (D), R18.2
unnamed: R4.2, U2.28
unnamed: R10.2, R11.1, U2.20
unnamed: R12.1, U2.23
unnamed: R24.1, U1.T7
unnamed: R25.1, U1.R2
unnamed: R26.1, U1.R4
unnamed: R27.1, U1.T2
unnamed: R39.2, U2.24
PIOBU1: U1.M3
PIOBU2: U1.P2
PIOBU3: U1.P4
PIOBU4: U1.N4
PIOBU5: U1.M5
PIOBU6: U1.N5
PIOBU7: U1.N3
PMIC_CHGLEV_PA12: U1.N17, U2.22
PMIC_IRQ_PB13: R9.2, U1.C5, U2.12
PMIC_LBO: R3.2, U1.M13, U2.19
POWER: J2.2, PB1.3, PB1.4, Q4.3 (D), R15.2
PWMEXTRG1-IRQ: J2.10, U1.B8
PWMH1: J2.6, U1.F5
PWMH2: J2.9, U1.A10
PWMH3: J2.7, U1.D5
PWML0: U1.P13
PWML1: J2.8, U1.C8
RESET: J1.1, R15.1, U2.9
RXD: U1.N2
SDMMC1_CD: R36.1, U1.R13
SDMMC1_CK: J6.5, U1.T17
SDMMC1_CMD: J6.3, R32.2, U1.R14
SDMMC1_DAT0: J6.7, R30.2, U1.T16
SDMMC1_DAT1: J6.8, R34.2, U1.T15
SDMMC1_DAT2: J6.1, R31.2, U1.P9
SDMMC1_DAT3: J6.2, R33.2, U1.P10
SHDN: Q1.1 (G), R2.1, R27.2
SPI0_MISO: J1.13, U1.M11
SPI0_MOSI: J1.12, U1.N16
SPI0_SCK: J1.11, U1.M17
STATUS-LED: D4.2 (A), U1.U17
STROBE: U1.U12
TCK: U1.K5; also elsewhere on the board
TMS: U1.K1; also elsewhere on the board
UART1_RX: J1.14, R14.2, U1.D8
UART1_TX: J1.15, U1.J1
USBA_M: J3.2 (D-), U1.T10
USBA_P: J3.3 (D+), U1.U10
USBB_M: J5.1, J7.2 (D-), U1.T11
USBB_P: J5.2, J7.3 (D+), U1.U11
VBAT: C11.1, C26.1, D3.1, J2.1, J4.1, R10.1, U2.29, U2.30
VBUS: C2.2, D3.2, J2.3, J3.1 (VBUS), J7.1 (VBUS), U2.33
VDDAUDIOPLL: C91.1, C95.1, L12.2, U1.M4
VDDBU: C54.1, C62.1, R16.1, U1.U5, U3.5
VDDCORE: C9.1, C15.1, C20.1, C22.1, C25.1, C27.1, C29.1, C31.1, C42.1, C46.1, C49.1, C53.1, C57.1, C60.1, FB6.2, FB7.2, L2.2, R17.2, U1.D7, U1.E9, U1.H2, U1.L12, U1.P7, U1.U3, U2.34
VDDFUSE: C17.1, C59.1, U1.N13, U2.4
VDDIODDR: C8.1, C14.1, C19.1, C23.1, C24.1, C30.1, C32.1, C33.1, C34.1, C36.1, C38.1, C43.1, C47.1, C50.1, C58.1, C61.1, C63.1, C64.1, C67.1, C69.1, C70.1, C71.1, C72.1, C73.1, C74.1, C75.1, C76.1, C77.1, C79.1, L1.2, R19.2, U1.A16, U1.B16, U1.C16, U1.D16, U1.E8, U1.E11, U1.E15, U1.E16, U1.F15, U1.G12, U1.G15, U1.G17, U1.H10, U1.H15, U1.J8, U1.J15, U1.J17, U1.K15, U1.L10, U1.L14, U1.L15, U1.L16, U2.2
VDDIOP0: C89.1, C92.1, FB3.1, U1.D4, U1.F3
VDDIOP1: C87.1, C88.1, FB2.1, U1.N12, U1.P12
VDDIOP2: C86.1, FB1.1, U1.D9
VDDOSC: C90.1, C93.1, L11.2, U1.N6
VDDUTMII: C94.1, FB4.1, U1.P6
VDD_3V3: C10.1, C16.1, C21.1, C28.1, C52.1, C56.1, C85.1, D5.2 (A), FB1.2, FB2.2, FB3.2, FB4.2, FB5.2, J1.2, J6.4, L3.2, NT2.2, R3.1, R7.1, R8.1, R9.1, R21.2, R23.2, R30.1, R31.1, R32.1, R33.1, R34.1, R37.2, U1.H3, U1.N8, U2.17
VDD_3V3_LP: C12.1, U2.5
VDD_AUX1: C6.1, U2.8
VDD_AUX2: C4.1, U2.7
VSYS_5V: C5.1, C7.1, C13.1, C18.1, D2.2 (A), R1.1, R5.1, R18.1, R22.1, U2.6, U2.16, U2.31, U2.32, U2.35, U2.39
WKUP: Q3.3 (D), R16.2, R25.2
nPBSTAT: Q5.1 (G), R22.2, U2.13

Notes on the sheet:
Power links
POWER
LEDs
Mounting Holes
USB
MicroSD
Header Pins
SWDIO

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
Board: 4 copper layers, 22.9 x 50.8 mm, 172 parts (86 on the bottom side), 100 nets.

Other parts of the board:
TCK: TestPoint; TestPoint_Pad_1.0x1.0mm
TMS: TestPoint; TestPoint_Pad_1.0x1.0mm

Their connections:
TCK: TCK.1; also elsewhere on the board
TMS: TMS.1; also elsewhere on the board

## Commit log

2020-02-14 First push
2020-04-30 Add PDF Schematic
2020-04-30 Add license
2020-10-29 Move symbols into a local library.
    Loading this project into KiCad showed there were missing symbol
    libraries. These appear to exist only on the hard drive of the original
    author. I have rescued these symbols from the cache file and moved them
    into a new local library (with the same name as the project).
    I also added a .gitignore to remove all the backup/temp files.
2020-10-29 Added part numbers to Manufacturer_Part_Number field.
    I went with Stackpole RMCF-series resistors and TDK caps, but any
    make of jellybean will likely do.
2020-10-29 Add 3d model objects
